
CORE_IMAGE_EXTRA_INSTALL:append = " \
    flutter-pi-release \
    rpi-weather \
"
